# Keil uVision project gpio_irq.uvprojx, settings and files
target gpio_irq_Release (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: HC32F005C6PA HDSC
  pack: HDSC.HC32F005.1.0.0
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: gpio_irq
  c flags: Optim=1 OneElfS=1 uC99=1
  c include: ..\source;..\..\HC32F005C6PA\mcu\common;..\..\HC32F005C6PA\driver\inc;..\source\inc
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32f005.s
    ../../HC32F005C6PA/mcu/common/: system_hc32f005.c
  group driver
    ../../HC32F005C6PA/driver/src/: ddl.c interrupts_hc32f005.c clk.c gpio.c adc.c adt.c bt.c crc.c flash.c i2c.c lpm.c lvd.c pca.c reset.c spi.c trim.c uart.c vc.c wdt.c
  group README
    ../: readme.txt
  group Hardware
    ../source/Hardware/: bsp_adc.c Bsp_i2c_gpio.c bsp_spi.c bsp_uart.c
  group Hal
    ../source/hal/: at24c02.c CMT2300drive.c key.c led.c
  group application
    ../source/application/: command.c common.c eeprom.c main.c uartParse.c
software components: CMSIS:CORE 5.1.1
