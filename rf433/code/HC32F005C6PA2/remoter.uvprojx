# Keil uVision project remoter.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32F005C6PA HDSC
  pack: HDSC.HC32F005.1.0.1
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: remoter
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\driver\inc;.\driver;.\Hardware\inc;.\mcu\common;.\platform;.\Hardware
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group driver
    ./driver/src/: adc.c adt.c bt.c clk.c crc.c ddl.c flash.c gpio.c i2c.c interrupts_hc32f005.c lpm.c lvd.c pca.c reset.c spi.c trim.c uart.c vc.c wdt.c
  group Hardware
    ./Hardware/: bsp_adc.c Bsp_i2c_gpio.c bsp_uart.c eeprom.c key.c led.c
  group application
    ./platform/: uartParse.c CMT2300drive.c bsp_spi.c at24c02.c command.c main.c
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.1
