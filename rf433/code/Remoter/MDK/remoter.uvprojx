# Keil uVision project remoter.uvprojx, settings and files
target remoter (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: HC32F005C6PA HDSC
  pack: HDSC.HC32F005.1.0.1
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: remoter
  c flags: Optim=1 OneElfS=1 uC99=1
  c include: ..\source;..\source\inc;..\HC32F005C6PA\driver\inc;..\HC32F005C6PA\mcu\common
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32f005.s
    ../HC32F005C6PA/mcu/common/: system_hc32f005.c
  group driver
    ../HC32F005C6PA/driver/src/: adc.c adt.c bt.c clk.c crc.c ddl.c flash.c gpio.c i2c.c interrupts_hc32f005.c lpm.c lvd.c pca.c reset.c spi.c trim.c uart.c vc.c wdt.c
  group README
    ../: readme.txt
  group Hardware
    ../source/Hardware/: bsp_adc.c Bsp_i2c_gpio.c bsp_spi.c bsp_uart.c cmt_spi3.c
  group Hal
    ../source/hal/: at24c02.c key.c led.c time_server.c
    ../source/radio/: cmt2300a_hal.c cmt2300a.c radio.c
  group application
    ../source/application/: command.c common.c eeprom.c main.c uartParse.c radio_TxRx.c
software components: CMSIS:CORE 5.1.1
