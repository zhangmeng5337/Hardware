# IAR project KEY_8.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: HC32F005C6PA HDSC HC32F005C6PA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG
  ICCARM.CCIncludePath2: ; ..\driver\inc; ..\mcu\common; ..\source; ..\source\driver\inc; ..\source\driver\platform; ..\source\driver\Hardware; ..\source\driver\src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: KEY_8.out
  ILINK.IlinkIcfFile: hc32f005.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group common
    ../driver/src/: ddl.c interrupts_hc32f005.c
    ./: startup_hc32f005.s
    ../mcu/common/: system_hc32f005.c
  group driver
    ../driver/src/: adc.c adt.c bt.c clk.c crc.c flash.c gpio.c i2c.c lpm.c lvd.c pca.c reset.c spi.c trim.c uart.c vc.c wdt.c
  group HAL
    ../source/driver/src/: at24c02.c command.c
    ../source/driver/platform/: uartParse.c
  group Hardware
    ../source/driver/Hardware/: bsp_adc.c Bsp_i2c_gpio.c bsp_uart.c eeprom.c key.c led.c
  group RF
    ../source/driver/src/: bsp_spi.c CMT2300drive.c
  group System
    ../source/driver/platform/: common.c
  group user
    ./: main.c
