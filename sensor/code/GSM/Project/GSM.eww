<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\GSM.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\..\..\magnetic\code\Iar_Stm8lSx1278_Beta\Project\lora.ewp</path>
    </project>
    <batchBuild />
</workspace>
