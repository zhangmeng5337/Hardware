# IAR project Backup of GSM.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenCodeModel: 0
  General.GenDataModel: 1
  ICCSTM8.IccLang: 0
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
