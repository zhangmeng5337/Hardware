# Keil uVision project mp3.uvprojx, settings and files
target MP3 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: mp3
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,   STM32F10X_HD
  c include: .\RTE;.\RTE\Device\STM32F103RC;..\Fatfs_0.09;..\Main\Inc;..\Driver\Inc;..\Device\Inc;..\App\Inc;..\SYSTEM\delay;..\SYSTEM\sys;..\Device\Src\OLED
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Main
    ../Main/Src/: main.c stm32f10x_it.c basic.c
  group Driver
    ../Driver/Src/: spi1.c spi2.c adc.c microsec.c stm3210e_eval_sdio_sd.c flash.c timer.c
  group Device
    ../Device/Src/: key.c led.c oled.c sdcard.c vs1053b.c power.c vs1053b_flac.c
    ../Device/Src/OLED/: oled2.c
  group App
    ../App/Src/: display.c keyscan.c mp3.c palysong.c test.c fatfs.c setting.c
    ../SYSTEM/delay/: delay.c
  group Fatfs009
    ../Fatfs_0.09/: diskio.c ff.c
    ../Fatfs_0.09/option/: cc936.c
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SDIO 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0
