# Keil uVision project ADUart.uvproj, settings and files
target ADUart (ARM-ADS)
  device: STM32F105RB STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x801FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: ADUart
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_CL
  c include: ..\Src\Libraries\CMSIS\CM3\CoreSupport;..\Src\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Src\Libraries\STM32_USB-FS-Device_Driver\inc;..\Src\Usr\UsbHid\inc;..\Src\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Src\Usr;..\Src\uCOS\uC-CPU;..\Src\uCOS\uC-CPU\ARM-Cortex-M3\RealView;..\Src\uCOS\uCOS-II\Source;..\Src\uCOS\uCOS-II\Ports\ARM-Cortex-M3\Generic\RealView;..\Src\uCOS\uC-LIB;..\Src\uCOS\uC-Board
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../Src/Usr/: main.c stm32f10x_it.c includes.h
  group Srartup
    ../Src/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s
  group CMSIS
    ../Src/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Src/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group SrdPeriph_Driver
    ../Src/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group uCOS/uC-CPU
    ../Src/uCOS/uC-CPU/: cpu_def.h
    ../Src/uCOS/uC-CPU/ARM-Cortex-M3/RealView/: cpu.h cpu_a.asm cpu_c.c
  group uCOS/uCOS-II/Source
    ../Src/uCOS/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group uCOS/uCOS-II/PORT
    ../Src/uCOS/uCOS-II/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uCOS/uC-LIB
    ../Src/uCOS/uC-LIB/: lib_str.h lib_def.h lib_mem.c lib_mem.h lib_str.c
    ../Src/uCOS/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group uCOS/uC-Board
    ../Src/uCOS/uC-Board/: app_cfg.h bsp.c bsp.h os_cfg.h
  group Uart
    ../Src/Usr/Uart/: Uart.c UartCom.c
  group AD_SPI1
    ../Src/Usr/AD_SPI1/: AD_SPI1.c
  group AD_SPI2
    ../Src/Usr/AD_SPI2/: AD_SPI2.c
  group AD_SPI3
    ../Src/Usr/AD_SPI3/: AD_SPI3.c
  group ATP
    ../Src/Usr/APT/: APT.C
  group Food
    ../Src/Usr/Food/: Food.c
