# Keil uVision project lcd.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000)
  output: lcd +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\stc8h8k64u_LCD
  group Source Group 1
    ./: main.c sys.c com.c
