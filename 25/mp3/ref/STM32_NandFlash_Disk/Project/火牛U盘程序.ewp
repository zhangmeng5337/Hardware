# IAR project 火牛U盘程序.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  ICCARM.CCIncludePath2: ..\Source; ..\Source\delay; ..\Source\SD_driver; ..\Source\USB_driver; ..\Source\USBLIB; ..\Source\User; ..\Libraries\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: 火牛U盘程序.srec
  ILINK.IlinkOutputFile: 火牛U盘程序.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group Libraries
    ../Libraries/src/: cortexm3_macro.s spi_flash.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_usart.c
  group Source
    ../Source/: stm32f10x_it.c
  group Source/delay
    ../Source/delay/: delay.c
  group Source/SD_driver
    ../Source/SD_driver/: SD_driver.c
  group Source/USB_driver
    ../Source/USB_driver/: usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c
  group Source/USBLIB
    ../Source/USBLIB/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group Source/User
    ../Source/: fsmc_nand.c hw_config.c main.c mass_mal.c memory.c scsi_data.c tft_lcd.c usart1_fun.c
  group Startup
    ../Libraries/startup/: stm32f10x_vector.s
