<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\&#x706B;&#x725B;U&#x76D8;&#x7A0B;&#x5e8F;.ewp</path>
  </project>
  <batchBuild/>
</workspace>


