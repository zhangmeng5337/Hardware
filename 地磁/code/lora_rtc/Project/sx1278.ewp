# IAR project sx1278.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151G6 STM8L151G6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\Library\inc; ..\Library\src; ..\App; ..\App\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: sx1278.hex
  ILINK.IlinkOutputFile: sx1278.hex
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\lnkstm8l151g6.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: UnspecifiedSTM8 STM8 - Unspecified
  ICCSTM8.CCDefines: NDEBUG
  ICCSTM8.CCIncludePath2: Z:\OS\others\Hardware\lora_rtc\Library\inc; Z:\OS\code\PARK\lora_rtc\App
  ILINK.IlinkOutputFile: sx1278.out
  group App
    ../App/: main.c stm8l15x_it.c sx1276-Fsk.c sx1276-lora.c sx1276.c sysclock.c uart1.c
  group Driver
    ../Driver/: RF.c
  group Hardware
    ../Hardware/: bsp.c
  group Libraries
    ../Library/src/: stm8l15x_adc.c stm8l15x_aes.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
