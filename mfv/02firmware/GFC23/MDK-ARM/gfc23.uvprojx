# Keil uVision project gfc23.uvprojx, settings and files
target gfc23 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32G473CETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: gfc23 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G473xx,BAREMETALx
  c include: ../USB_Device/App;../USB_Device/Target;../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../Application/inc;../Application/src/ethercat/SSC/Src;../Application/inc/ethercat;../Application/inc/v1
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32g473xx.s
  group Application/User/Core
    ../Application/: memorymap.txt
    ../Core/Src/: main.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Application/User/USB_Device/Target
    ../USB_Device/Target/: usbd_conf.c
  group Application/User/USB_Device/App
    ../USB_Device/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_pcd.c stm32g4xx_hal_pcd_ex.c stm32g4xx_ll_usb.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_iwdg.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Application/GFC
    ../Application/src/v1/hal/: app.c cdg.c relay_driver.c config.c verifier.c adc.c debug.c filter.c pt100.c
    ../Application/src/v1/hardware/: uart.c
    ../Application/src/v1/: mystring.c cmd_queue.c calibration.c gas.c flash.c stmflash.c
  group Application/Threads
    ../Application/src/tasks/: semTaskbgnd.c semTaskcomms.c semTaskecat.c semTaskmem.c semTasksigproc.c
  group Application/Utilities
    ../Application/src/utilities/: crc16.c libSearch.c libUnits.c utilities.c
  group Application/Crypto
    ../Application/src/crypto/: aes.c
    ../Application/src/bootloader/src/: key.c
  group Application/Communications
    ../Application/src/signalprocessing/: streaming.c
    ../Application/src/communications/: cmdConfiguration.c cmdFirmware.c cmdList.c protocol.c
  group Application/Memory
    ../Application/src/memory/: nvmem.c
  group Application/API
    ../Application/src/api/: commsAPI.c digitalIO.c
  group Application/Bootloader
    ../Application/src/bootloader/src/: bootloader.c
  group Application/EtherCAT
    ../Application/src/ethercat/SSC/Src/: bootmode.c coeappl.c ecatappl.c ecatcoe.c ecatfoe.c ecatslv.c foeappl.c mailbox.c objdef.c sdoserv.c ETG5003_2020_MFC.c
    ../Application/src/ethercat/SSC/Application/src/: 9252_HW.c SPIDriver.c
  group Application/Modbus
    ../Application/src/modbus/: modbus.c
target Bootloader (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32G473CETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.0
  cpu: as above
  output: gfc23BL +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G473xx,BOOTLOADER,BAREMETALx
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0xf000
  memory RVCT9: RAM 0x20000000 size 0x20000
target Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32G473CETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.0
  cpu: as above
  output: gfc23REL +hex
  AfterMake: ..\Application\src\bootloader\axftobinMDK5.bat
  AfterMake: ..\Application\src\bootloader\encrypt.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G473xx,RELEASE,BAREMETALx
  c include: as above
  memory RVCT4: ROM 0x8010000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x20000
software components: CMSIS:CORE 5.3.0, CMSIS:DSP 1.15.0, CMSIS:RTOS2:Keil RTX5 5.5.1, Device:Startup 1.4.0
