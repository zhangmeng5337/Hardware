<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\RHR075_GFC_ECAT_DNET_RS485_ALL.ewp</path>
  </project>
  <batchBuild />
</workspace>
