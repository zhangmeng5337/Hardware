# Keil uVision project T5L_OS.uvproj, settings and files
target Target 1 (MCS-51)
  device: T5 DWIN
  cpu: IRAM(0-0xFF) CLOCK(24000000) MODC2 PMW DPC BSE MDU_R515
  output: T5L51 +hex
  AfterMake: .\1.bat
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\T5L51;.\app
  group user
    ./: STARTUP_M5.A51 main.c sys.c uart.c Function.c
  group app
    ./app/: Led.c i2c.c i2c.h save_data_dgus.c
    ./: crc16.c
