# Keil uVision project atk_f407.uvprojx, settings and files
target uC-OS2 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: atk_f407 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ..\..\User;..\..\Drivers;..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\Drivers\CMSIS\Include;..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\Middlewares;..\..\Middlewares\uC-OS2\uC-CPU\ARM-Cortex-M\ARMv7-M\ARM;..\..\Middlewares\uC-OS2\uC-CPU\Cfg\Template;..\..\Middlewares\uC-OS2\uC-CPU;..\..\Middlewares\uC-OS2\uC-LIB\Cfg\Template;..\..\Middlewares\uC-OS2\uC-LIB;..\..\Middlewares\uC-OS2\uC-OS2\Cfg\Template;..\..\Middlewares\uC-OS2\uC-OS2\Ports\ARM-Cortex-M\ARMv7-M\ARM;..\..\Middlewares\uC-OS2\uC-OS2\Source
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group User
    ../../User/: main.c stm32f4xx_it.c uc-os2_demo.c
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_usart.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_sram.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash.c
  group Drivers/BSP
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/LCD/: lcd.c
    ../../Drivers/BSP/KEY/: key.c
    ../../Drivers/BSP/SRAM/: sram.c
    ../../Drivers/BSP/24CXX/: 24cxx.c
    ../../Drivers/BSP/BEEP/: beep.c
    ../../Drivers/BSP/IIC/: myiic.c
    ../../Drivers/BSP/TOUCH/: ctiic.c ft5206.c gt9xxx.c touch.c
  group Middlewares/MALLOC
    ../../Middlewares/MALLOC/: malloc.c
  group Middlewares/uC-OS2/BSP
    ../../Middlewares/uC-OS2/uC-CPU/BSP/Template/: bsp_cpu.c
  group Middlewares/uC-OS2/CPU
    ../../Middlewares/uC-OS2/uC-CPU/ARM-Cortex-M/ARMv7-M/ARM/: cpu_a.asm
    ../../Middlewares/uC-OS2/uC-CPU/ARM-Cortex-M/ARMv7-M/: cpu_c.c
    ../../Middlewares/uC-OS2/uC-CPU/: cpu_core.c
  group Middlewares/uC-OS2/LIB
    ../../Middlewares/uC-OS2/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group Middlewares/uC-OS2/OS2
    ../../Middlewares/uC-OS2/uC-OS2/Cfg/Template/: app_hooks.c
    ../../Middlewares/uC-OS2/uC-OS2/Ports/ARM-Cortex-M/ARMv7-M/ARM/: os_cpu_a.asm os_dbg.c
    ../../Middlewares/uC-OS2/uC-OS2/Ports/ARM-Cortex-M/ARMv7-M/: os_cpu_c.c
    ../../Middlewares/uC-OS2/uC-OS2/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group Readme
    ../../: readme.txt
