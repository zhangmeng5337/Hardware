# Keil uVision project code.uvprojx, settings and files
target code (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: app +hex
  AfterMake: fromelf --bin --output .\..\firmware\application.bin   .\code\app.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F405xx,USE_HAL_DRIVER,STM32F405xx
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Src/1158;../Inc/ota;../Src/pid
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f405xx.s
  group Application/User
    ../Src/: app.c main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
    ../Src/ota/: my_string.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group hardware
    ../Src/: di.c uart.c
  group hal
    ../Src/: do.c pt100.c sys.c modbus.c crc.c rs485.c lte_hal.c lcd.c mqtt_analy.c config.c equipment_ctrl.c water_ctrl.c filter.c hotter.c machine_ctrl.c rtc.c schedule.c
    ../Src/1158/: ads1258.c hal.c ai_proc.c
    ../Src/ota/: stmflash.c update.c
    ../Src/pid/: FuzzyPID.c pid.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_iwdg.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
software components: CMSIS:CORE 5.6.0
