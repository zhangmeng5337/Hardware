# Keil uVision project 三相多功能全功能.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8052AH Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: 多功能奇偶STC8H2K +hex
  c flags: Optimize=9 SizeSpeed=1
  group Source Group 1
    ./: 多功能.c 24c02.H 12864.H canshu.H ds1302.H ht7038.H STC8F.h
