# Keil uVision project 数码管STC8H1K08.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80C51FA Intel
  cpu: IRAM(0-0xFF) CLOCK(20000000)
  output: 数码管 +hex
  c flags: Optimize=9 SizeSpeed=1
  group Source Group 1
    ./: shikong.c iar.asm hardware.c
