# Keil uVision project 双层照明模块时控面板STC8H4KTLCD自带时钟.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80C51FA Intel
  cpu: IRAM(0-0xFF) CLOCK(20000000)
  output: STC8H4K64TLCD双层照明模块16路时控显示板12M +hex
  c flags: Optimize=9 SizeSpeed=1
  group Source Group 1
    ./: shikong.c iar.asm
