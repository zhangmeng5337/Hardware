# Keil uVision project 无IIC短款三相电流+DIDO.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8F2K64S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x07FF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: 无IIC短款三相电流STC8H17+DIDO +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\bl0930f
  group Source Group 1
    ./: main.c ht7038.c 12864.c
