# Keil uVision project TM7780.uvproj, settings and files
target TM7780 (MCS-51)
  device: STC8H1K08T Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000)
  output: TM7780 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\inc;C:\Keil_v5\C51\LIB
  group Source
    ./: TM7780.c
    ./src/: hardware.c uart.c main.c crc.c app.c modbus.c eeprom.c timer.c
