# Keil uVision project lcd.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8F2K64S4 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x07FF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: 无IIC短款三相电流STC8H17+DIDO +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\STC8H1K17+DIDO
  group Source Group 1
    ./: main.c sys.c lcd_driver.c lcd_app.c
