# Keil uVision project sensor.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: CW32L010F8 WHXY
  pack: WHXY.CW32L010_DFP.1.0.0
  cpu: IRAM(0x20000000,0x01000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 wLevel=2
  c include: ..\USER\inc;.\IDEsupport\MDK;..\Libraries\inc;..\USER\src\CS1237;..\USER\src\KALMAN
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --keep=*Handler
  group Startup
    C:/Keil_v5/ARM/PACK/Keil/WHXY.CW32L010_DFP/Device/Source/ARM/: startup_cw32l010.s
    ../Libraries/src/: system_cw32l010.c
  group User
    ../USER/src/: main.c interrupts_cw32l010.c cw32_eval_spi_flash.c cmd_queue.c uart_hal.c 74hc595.c display.c modbus.c crc.c app.c sensor.c flash.c reg.c key.c
    ../USER/src/CS1237/: cs1237.c
    ../USER/src/KALMAN/: kalman.c
  group Driver
    ../Libraries/src/: cw32l010_adc.c cw32l010_atim.c cw32l010_btim.c cw32l010_crc.c cw32l010_debug.c cw32l010_digitalsign.c cw32l010_flash.c cw32l010_gpio.c cw32l010_gtim.c cw32l010_i2c.c cw32l010_iwdt.c cw32l010_lptim.c cw32l010_lvd.c cw32l010_pwr.c cw32l010_rtc.c cw32l010_spi.c cw32l010_sysctrl.c cw32l010_systick.c cw32l010_uart.c cw32l010_vc.c
software components: CMSIS:CORE 5.3.0
