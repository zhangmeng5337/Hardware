# Keil uVision project STC15W4K_Template.uvproj, settings and files
target CS1237读写 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: CS1237读写 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\System;..\Code_User
  group Code_User
    ../Code_User/: main.c Uart_1.c T4_Key.c CS1237.c
  group System
    ../System/: STC15W.h
  group 例程说明
    ../: 例程说明.txt
