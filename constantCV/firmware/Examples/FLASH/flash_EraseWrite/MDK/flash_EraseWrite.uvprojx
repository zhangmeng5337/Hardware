# Keil uVision project flash_EraseWrite.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F030C6Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 wLevel=2
  c include: ..\..\..\..\IdeSupport\MDK;..\..\..\..\Libraries\inc;..\USER\inc;..\..\..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --keep=*Handler
  group Startup
    ../../../../IdeSupport/MDK/: startup_cw32l010.s
    ../../../../Libraries/src/: system_cw32l010.c
  group User
    ../USER/src/: main.c interrupts_cw32l010.c
  group Driver
    ../../../../Libraries/src/: cw32l010_flash.c cw32l010_gpio.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.6.0
