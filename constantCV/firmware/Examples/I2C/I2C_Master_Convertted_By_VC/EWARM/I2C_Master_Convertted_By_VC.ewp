# IAR project I2C_Master_Convertted_By_VC.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: CW32L010x8 WHXY CW32L010x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\USER\inc; ..\..\..\..\Libraries\inc; ..\..\..\..\IdeSupport\EWARM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: I2C_Master_Convertted_By_VC.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\WHXY\CW32L010x8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration debug (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: __DEBUG
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkIcfFile: HC32F030.icf
  group Doc
    ../: readme.txt
  group Driver
    ../../../../Libraries/src/: cw32l010_adc.c cw32l010_atim.c cw32l010_awt.c cw32l010_btim.c cw32l010_crc.c cw32l010_debug.c cw32l010_digitalsign.c cw32l010_dma.c cw32l010_eau.c cw32l010_flash.c cw32l010_gpio.c cw32l010_gtim.c cw32l010_i2c.c cw32l010_iwdt.c cw32l010_lptim.c cw32l010_lvd.c cw32l010_opamp.c cw32l010_pwr.c cw32l010_ram.c cw32l010_rtc.c cw32l010_spi.c cw32l010_sysctrl.c cw32l010_systick.c cw32l010_uart.c cw32l010_vc.c cw32l010_wwdt.c
  group Startup
    ../../../../IDEsupport/EWARM/: startup_cw32l010.s
    ../../../../Libraries/src/: system_cw32l010.c
  group User
    ../USER/src/: interrupts_cw32l010.c main.c
