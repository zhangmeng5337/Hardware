<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\I2C_Master_Convertted_By_VC.ewp</path>
  </project>
  <batchBuild/>
</workspace>


