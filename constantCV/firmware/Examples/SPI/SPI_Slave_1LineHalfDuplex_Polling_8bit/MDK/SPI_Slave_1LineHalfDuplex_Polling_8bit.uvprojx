# Keil uVision project SPI_Slave_1LineHalfDuplex_Polling_8bit.uvprojx, settings and files
target SPI_Slave_1LineHalfDuplex_Polling_8bit (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: CW32L010F8 WHXY
  pack: WHXY.CW32L01x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x01000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: SPI_Slave_1LineHalfDuplex_Polling_8bit +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\..\..\IdeSupport\MDK;..\..\..\..\Libraries\inc;..\USER\inc;..\..\..\..\StartKit_Board
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --keep=*Handler
  group Startup
    ../../../../IDEsupport/MDK/: startup_cw32l010.s
    ../../../../Libraries/src/: system_cw32l010.c
  group User
    ../USER/src/: main.c interrupts_cw32l010.c
  group Driver
    ../../../../Libraries/src/: cw32l010_gpio.c cw32l010_spi.c cw32l010_sysctrl.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.6.0
