# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CW32L010x8 WHXY CW32L010x8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\..\..\IdeSupport\EWARM; ..\..\..\..\Libraries\inc; ..\USER\inc; ..\..\..\..\Utilities; E:\WorkSoft\IAR EWARM\arm\CMSIS\Core\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: CW32L052x8 WHXY CW32L052x8
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\USER\inc; ..\..\..\..\IdeSupport\EWARM; ..\..\..\..\Libraries\inc; ..\..\..\..\Utilities
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: Project.hex
  group Doc
    ../: readme.txt
  group Driver
    ../../../../Libraries/src/: cw32l010_gpio.c cw32l010_gtim.c cw32l010_sysctrl.c cw32l010_uart.c
  group Startup
    ../../../../IdeSupport/EWARM/: startup_cw32l010.s
    ../../../../Libraries/src/: system_cw32l010.c
  group User
    ../USER/src/: interrupts_cw32l010.c lin.c main.c
