# Keil uVision project DigitalSign.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CW32L010F8 WHXY
  pack: WHXY.CW32L01x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x01000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 wLevel=2
  c define: CW32L010xx
  c include: ..\..\..\..\IdeSupport\MDK;..\..\..\..\Libraries\inc;..\USER\inc;..\..\..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --keep=*Handler
  group Startup
    ../../../../IDEsupport/MDK/: startup_cw32l010.s
    ../../../../Libraries/src/: system_cw32l010.c
  group User
    ../USER/src/: main.c interrupts_cw32l010.c
  group Driver
    ../../../../Libraries/src/: cw32l010_digitalsign.c cw32l010_sysctrl.c cw32l010_gpio.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.4.0
