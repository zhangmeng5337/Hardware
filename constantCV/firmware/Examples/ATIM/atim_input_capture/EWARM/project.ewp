# IAR project project.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: CW32L010x8 WHXY CW32L010x8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\USER\inc; ..\..\..\..\Libraries\inc; ..\..\..\..\IdeSupport\EWARM; ..\..\..\..\Utilities
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration debug (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: CW32L010 CW32L010
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: __DEBUG
  ICCARM.CCIncludePath2: ..\USER\inc; ..\..\..\..\Libraries\inc; ..\..\..\..\IdeSupport\EWARM
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\CW\cw32l031.icf
  group Doc
    ../: readme.txt
  group Driver
    ../../../../Libraries/src/: cw32l010_atim.c cw32l010_btim.c cw32l010_gpio.c cw32l010_sysctrl.c cw32l010_systick.c
  group Startup
    ../../../../IdeSupport/EWARM/: startup_cw32l010.s
    ../../../../Libraries/src/: system_cw32l010.c
  group User
    ../USER/src/: interrupts_cw32l010.c main.c
